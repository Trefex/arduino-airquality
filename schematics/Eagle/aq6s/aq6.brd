File: schematics/Eagle/aq6s/aq6.brd (EAGLE design)
At the start: 99.8 x 66.8 mm, 24 parts

Commit message: pcb and code updates
Routing:
- net GND: track 62.9 -> 68.0 mm, vias 0 -> 1
